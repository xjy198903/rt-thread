# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; CPU_MIMXRT1176DVMAA_cm7; XIP_BOOT_HEADER_ENABLE=0; XIP_BOOT_HEADER_DCD_ENABLE=0; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; ARM_MATH_CM7; USE_SDRAM; SOC_IMXRT1170_SERIES; __USE_SHMEM; DATA_SECTION_IS_CACHEABLE=1; ENDIANNESS; USE_RTOS; CORE1_IMAGE_COPY_TO_RAM; __RTTHREAD__; sprintf=rt_sprintf; snprintf=rt_snprintf; printf=rt_kprintf
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\..\components\libc\compilers\common\extension; ..\..\libraries\MIMXRT1170\MIMXRT1176; ..\..\..\..\components\dfs\include; ..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif; ..\..\libraries\MIMXRT1170\CMSIS\Include; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\drivers\usb\usbhost\include; ..\..\..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\..\..\components\libc\posix\io\stdio; ..\..\libraries\drivers\rpmsg\rpmsg_lite\include; ..\..\libraries\MIMXRT1170\MIMXRT1176\drivers\cm7; ..\..\libraries\drivers; ..\..\..\..\libcpu\arm\cortex-m7; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\dfs\filesystems\romfs; .; xip; ..\..\libraries\drivers\rpmsg\mcmgr; board; ..\..\libraries\MIMXRT1170\MIMXRT1176\drivers; ..\..\..\..\components\net\netdev\include; ..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\posix; ..\..\..\..\components\drivers\usb\usbhost\core; ..\..\..\..\components\drivers\include; ..\..\..\..\components\net\lwip\port; board\MCUX_Config; ..\..\..\..\components\drivers\usb\usbhost\class; board\ports; ..\..\..\..\components\dfs\filesystems\elmfat; applications; ..\..\..\..\include; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\dfs\filesystems\devfs; ..\..\..\..\components\finsh; ..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4; ..\..\..\..\components\drivers\usb\usbhost
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkKeepSymbols: _rpmsg_lite_pingpong_cm4_image
  ILINK.IlinkConfigDefines: __use_shmem__=1
  ILINK.IlinkIcfFile: board\linker_scripts\cm7_sdram_txt.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: fpga_config.c cnc_can.c main.c mnt.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/can/: can.c
    ../../../../components/drivers/cputime/: cputime.c
    ../../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/misc/: pin.c
    ../../../../components/drivers/phy/: phy.c
    ../../../../components/drivers/rtc/: rtc.c
    ../../../../components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c dcd.c
    ../../libraries/drivers/: drv_boot_secondary_core.c drv_can.c drv_common.c drv_eth.c drv_flexspi.c drv_gpio.c drv_mdio.c drv_rtc.c drv_rtl8211f.c drv_sdio.c drv_sdram.c drv_uart.c drv_usbh.c
    ../../libraries/drivers/rpmsg/mcmgr/: mcmgr.c mcmgr_internal_core_api_imxrt1170.c mcmgr_mu_internal.c
    ../../libraries/drivers/rpmsg/rpmsg_lite/common/: llist.c
    ../../libraries/drivers/rpmsg/rpmsg_lite/rpmsg_lite/porting/: rpmsg_env.c rpmsg_platform.c
    ../../libraries/drivers/rpmsg/rpmsg_lite/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c
    ../../libraries/drivers/rpmsg/rpmsg_lite/virtio/: virtqueue.c
    ../../libraries/drivers/usb/host/: usb_host_devices.c usb_host_ehci.c usb_host_framework.c usb_host_hci.c
    ../../libraries/drivers/usb/phy/: usb_phy.c
  group Filesystem
    ../../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    ../../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../../libraries/MIMXRT1170/MIMXRT1176/drivers/: fsl_enet.c fsl_flexspi.c fsl_pmu.c generic_list.c fsl_os_abstraction_rtthread.c fsl_lpuart.c fsl_gpio.c fsl_mu.c fsl_snvs_lp.c fsl_anatop_ai.c fsl_dcdc.c fsl_common_arm.c fsl_usdhc.c fsl_flexcan.c fsl_snvs_hp.c fsl_common.c fsl_semc.c fsl_clock.c
    ../../libraries/MIMXRT1170/MIMXRT1176/: system_MIMXRT1176_cm7.c
    ../../libraries/MIMXRT1170/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
    ../../libraries/MIMXRT1170/MIMXRT1176/drivers/cm7/: fsl_cache.c
  group lwIP
    ../../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group rt_kprintf
    packages/rt_kprintf_threadsafe-latest/: rt_kprintf.c
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group rt_usbh
    ../../../../components/drivers/usb/usbhost/class/: mass.c udisk.c
    ../../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    ../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group xip
    xip/: evkmimxrt1170_flexspi_nor_config.c fsl_flexspi_nor_boot.c
